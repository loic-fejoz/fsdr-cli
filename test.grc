options:
  parameters:
    author: fsdr-cli
    generate_options: qt_gui
    id: fsdrcli
    output_language: python
    title: Created by fsdr-cli
  states: {}

blocks:
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_5
  id: blocks_file_sink
  parameters:
    file: '-'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '-'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_4
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_binary_slicer_fb_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: pattern_search_3
  id: pattern_search
  parameters:
    pattern_values: 1,0,1,1,1,0,1,1,1,1,1,1,0,0,1,0,0,1,1,0,0,0,0,0,1,0,0,1,1,1
    values_after: '1920'
  states: {}

connections:
- [blocks_complex_to_real_1, '0', digital_binary_slicer_fb_2, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_1, '0']
- [blocks_pack_k_bits_bb_4, '0', blocks_file_sink_5, '0']
- [digital_binary_slicer_fb_2, '0', pattern_search_3, '0']
- [pattern_search_3, '0', blocks_pack_k_bits_bb_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
