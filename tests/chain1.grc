options:
  parameters:
    author: loic
    generate_options: qt_gui
    id: chain1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.001953125'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/loic/projets/fsdr-cli/tests/france-culture-extract-output.i16
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/loic/projets/fsdr-cli/tests/france-culture-extract.u8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '256'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_float_to_short_0, '0']
- [analog_fm_deemph_0, '0', blocks_throttle_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_deinterleave_0, '0']
- [blocks_deinterleave_0, '0', blocks_float_to_complex_0, '0']
- [blocks_deinterleave_0, '1', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_float_to_complex_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
