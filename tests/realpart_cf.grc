options:
  parameters:
    author: loic
    generate_options: qt_gui
    id: realpart_cf
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fsdr-output.bin
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/fsdr-test.bin
    repeat: 'False'
    type: complex
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
