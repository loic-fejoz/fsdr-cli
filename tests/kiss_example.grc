options:
  parameters:
    author: loic
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: kissexample
    output_language: python
    title: kiss_example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: satellites_fixedlen_to_pdu_0
  id: satellites_fixedlen_to_pdu
  parameters:
    pack: 'False'
    packet_len: '240'
    packet_len_tag_key: '""'
    syncword_tag: ''
    type: byte
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    file: /tmp/output.kiss
  states: {}
- name: satellites_kiss_file_source_0
  id: satellites_kiss_file_source
  parameters:
    file: tests/test.kiss
  states: {}

connections:
- [pdu_pdu_to_stream_x_0, '0', satellites_fixedlen_to_pdu_0, '0']
- [satellites_fixedlen_to_pdu_0, pdus, satellites_kiss_file_sink_0, in]
- [satellites_kiss_file_source_0, out, pdu_pdu_to_stream_x_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
