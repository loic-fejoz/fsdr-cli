options:
  parameters:
    author: loic
    generate_options: qt_gui
    id: chain1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '88300'
  states: {}
- name: src_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '64'
    long_form: 'True'
    type: cc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: src_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: src_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: src_rate
    fbw: '0.4'
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: src_rate
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']
- [soapy_hackrf_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [soapy_hackrf_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
